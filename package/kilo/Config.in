## package/kilo/Config.in
```kconfig
config BR2_PACKAGE_KILO
        bool "kilo"
        help
          a small text editor
```
